inherit setuptools python-backports-init
require python-configparser.inc
